FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRCREV = "49cb1b34d759aa7a51269ca0f58fcc1f9647da5b"
SRC_URI += "\
        file://0001-imxvpuapi2_imx6_coda-remove-one-imx_coda_vpu_unload.patch \
        "
